# Keil uVision project remote_audio_ref.uvproj, settings and files
target remote_audio_ref (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: remote_audio_ref +hex
  c flags: Optim=4 wLevel=2
  c misc: --c99 --thumb -c --preinclude da14580_config.h --preinclude module_config.h --feedback=".\unused.txt"
  c include: ..\remote_audio;..\remote_audio\config;..\..\..\src\dialog\include;..\..\..\src\ip\ble\hl\src\host\att;..\..\..\src\ip\ble\hl\src\host\att\attc;..\..\..\src\ip\ble\hl\src\host\att\attm;..\..\..\src\ip\ble\hl\src\host\att\atts;..\..\..\src\ip\ble\hl\src\host\gap;..\..\..\src\ip\ble\hl\src\host\gap\gapc;..\..\..\src\ip\ble\hl\src\host\gap\gapm;..\..\..\src\ip\ble\hl\src\host\gatt;..\..\..\src\ip\ble\hl\src\host\gatt\gattc;..\..\..\src\ip\ble\hl\src\host\gatt\gattm;..\..\..\src\ip\ble\hl\src\host\l2c\l2cc;..\..\..\src\ip\ble\hl\src\host\l2c\l2cm;..\..\..\src\ip\ble\hl\src\host\smp;..\..\..\src\ip\ble\hl\src\host\smp\smpc;..\..\..\src\ip\ble\hl\src\host\smp\smpm;..\..\..\src\ip\ble\hl\src\profiles;..\..\..\src\ip\ble\hl\src\profiles\bas\bass;..\..\..\src\ip\ble\hl\src\profiles\dis\diss;..\..\..\src\ip\ble\hl\src\profiles\hogp;..\..\..\src\ip\ble\hl\src\profiles\hogp\hogpd;..\..\..\src\ip\ble\hl\src\profiles\spota\spotar;..\..\..\src\ip\ble\hl\src\profiles\streamdata\streamdatad;..\..\..\src\ip\ble\hl\src\profiles\streamdata\streamdatah;..\..\..\src\ip\ble\hl\src\rwble_hl;..\..\..\src\ip\ble\ll\src\controller\em;..\..\..\src\ip\ble\ll\src\controller\llc;..\..\..\src\ip\ble\ll\src\controller\lld;..\..\..\src\ip\ble\ll\src\controller\llm;..\..\..\src\ip\ble\ll\src\hcic;..\..\..\src\ip\ble\ll\src\rwble;..\..\..\src\modules\app\api;..\..\..\src\modules\app\src;..\..\..\src\modules\app\src\app_profiles\bass;..\..\..\src\modules\app\src\app_profiles\diss;..\..\..\src\modules\app\src\app_profiles\spotar;..\..\..\src\modules\app\src\app_project\remote_audio;..\..\..\src\modules\app\src\app_project\remote_audio\audio439;..\..\..\src\modules\app\src\app_project\remote_audio\common;..\..\..\src\modules\app\src\app_project\remote_audio\motion_sensor;..\..\..\src\modules\app\src\app_project\remote_audio\stream;..\..\..\src\modules\app\src\app_project\remote_audio\system;..\..\..\src\modules\app\src\app_project\spotar_fh;..\..\..\src\modules\app\src\app_utils;..\..\..\src\modules\app\src\app_utils\app_alt_pair;..\..\..\src\modules\app\src\app_utils\app_console;..\..\..\src\modules\app\src\app_utils\app_dbg;..\..\..\src\modules\app\src\app_utils\app_flash;..\..\..\src\modules\app\src\app_utils\app_multi_bond;..\..\..\src\modules\app\src\keyboard;..\..\..\src\modules\app\src\modules\app\src\app_utils\app_alt_pair;..\..\..\src\modules\common\api;..\..\..\src\modules\dbg\api;..\..\..\src\modules\display\api;..\..\..\src\modules\gtl\api;..\..\..\src\modules\gtl\src;..\..\..\src\modules\ke\api;..\..\..\src\modules\ke\src;..\..\..\src\modules\nvds\api;..\..\..\src\modules\rf\api;..\..\..\src\modules\rwip\api;..\..\..\src\plf\refip\src\arch;..\..\..\src\plf\refip\src\arch\boot\rvds;..\..\..\src\plf\refip\src\arch\compiler\rvds;..\..\..\src\plf\refip\src\arch\ll\rvds;..\..\..\src\plf\refip\src\driver\adc;..\..\..\src\plf\refip\src\driver\battery;..\..\..\src\plf\refip\src\driver\emi;..\..\..\src\plf\refip\src\driver\flash;..\..\..\src\plf\refip\src\driver\gpio;..\..\..\src\plf\refip\src\driver\i2c_BMI055;..\..\..\src\plf\refip\src\driver\i2c_eeprom;..\..\..\src\plf\refip\src\driver\intc;..\..\..\src\plf\refip\src\driver\led;..\..\..\src\plf\refip\src\driver\pwm;..\..\..\src\plf\refip\src\driver\reg;..\..\..\src\plf\refip\src\driver\spi;..\..\..\src\plf\refip\src\driver\spi_439;..\..\..\src\plf\refip\src\driver\spi_flash;..\..\..\src\plf\refip\src\driver\syscntl;..\..\..\src\plf\refip\src\driver\timer;..\..\..\src\plf\refip\src\driver\uart;..\..\..\src\plf\refip\src\driver\wkupct_quadec;c:\Keil\ARM\CMSIS\Include;C:\Keil\ARM\RV31\INC;C:\Keil_v5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x5000
  scatter file: ..\..\..\scatterfiles\scatterfile_common_debug.sct
  link misc: --any_placement=best_fit --datacompressor off --feedback=".\unused.txt" --remove ..\..\..\misc\rom_symdef.txt --symdefs=remote_audio_ref_sysram_symdef.txt --keep gapm.o(timeout_table_area) --keep jump_table.o(*) --keep nvds.o(*) --datacompressor off
  group app
    ../../../src/modules/app/src/: app.c app_sec.c app_sec_task.c app_task.c
    ../../../src/modules/app/src/app_project/remote_audio/audio439/: app_audio_codec.c app_audio439.c
    ../../../src/modules/app/src/app_profiles/bass/: app_batt.c app_batt_task.c
    ../../../src/modules/app/src/app_utils/app_multi_bond/: app_con_fsm.c app_con_fsm_task.c app_multi_bond.c app_white_list.c
    ../../../src/modules/app/src/app_utils/app_console/: app_console.c
    ../../../src/modules/app/src/app_utils/app_dbg/: app_dbg.c
    ../../../src/modules/app/src/app_profiles/diss/: app_dis.c app_dis_task.c
    ../../../src/modules/app/src/app_utils/app_flash/: app_flash.c
    ../../../src/modules/app/src/app_project/remote_audio/: app_kbd.c app_kbd_leds.c app_kbd_proj.c app_kbd_proj_task.c app_kbd_scan_fsm.c
    ../../../src/modules/app/src/app_project/remote_audio/motion_sensor/: app_motion_sensor.c app_motion_sensor_test.c
    ../../../src/modules/app/src/app_project/remote_audio/stream/: app_stream.c
    ../../../src/modules/app/src/app_utils/: app_utils.c
  group arch
    ../../../src/plf/refip/src/arch/main/ble/: arch_main.c arch_patch.c arch_sleep.c arch_system.c hardfault_handler.c jump_table.c nmi_handler.c
    ../../../src/modules/app/src/app_project/remote_audio/system/: periph_setup.c
  group include-api
    ../../../src/modules/app/api/: app.h app_api.h app_sec.h app_sec_task.h app_sw_version.h app_task.h app_task_handlers.h
  group include-config
    ./config/: app_audio439_config.h app_con_fsm_config.h app_flash_config.h app_kbd_config.h designs.h hw_config.h memory_config.h
  group include-project
    ./: da14580_config.h da14580_scatter_config.h da14580_stack_config.h module_config.h
  group include-app_project
    ../../../src/modules/app/src/app_project/remote_audio/: app_kbd.h app_kbd_debug.h app_kbd_hid_sensor.h app_kbd_key_matrix.h app_kbd_key_matrix_setup_0.h app_kbd_key_matrix_setup_1.h app_kbd_key_matrix_setup_2.h app_kbd_key_matrix_setup_3.h app_kbd_key_matrix_setup_4.h app_kbd_key_matrix_setup_5.h app_kbd_key_matrix_setup_6.h app_kbd_key_matrix_setup_7.h app_kbd_key_matrix_setup_8.h app_kbd_key_matrix_setup_9.h app_kbd_key_matrix_setup_10.h app_kbd_key_matrix_setup_11.h app_kbd_key_matrix_setup_12.h app_kbd_key_matrix_setup_13.h app_kbd_key_matrix_setup_14.h app_kbd_key_matrix_setup_15.h app_kbd_key_matrix_setup_16.h app_kbd_key_matrix_setup_17.h app_kbd_leds.h app_kbd_macros.h app_kbd_matrix.h app_kbd_matrix_setup_0.h app_kbd_matrix_setup_1.h app_kbd_matrix_setup_2.h app_kbd_matrix_setup_3.h app_kbd_matrix_setup_4.h app_kbd_matrix_setup_5.h app_kbd_matrix_setup_6.h app_kbd_matrix_setup_7.h app_kbd_matrix_setup_8.h app_kbd_matrix_setup_9.h app_kbd_matrix_setup_10.h app_kbd_matrix_setup_11.h app_kbd_matrix_setup_12.h app_kbd_matrix_setup_13.h app_kbd_matrix_setup_14.h app_kbd_matrix_setup_15.h app_kbd_matrix_setup_16.h app_kbd_matrix_setup_17.h app_kbd_proj.h app_kbd_proj_task.h app_kbd_scan_fsm.h
  group include-audio439
    ../../../src/modules/app/src/app_project/remote_audio/audio439/: app_audio_codec.h app_audio439.h
  group include-motion_sensor
    ../../../src/modules/app/src/app_project/remote_audio/motion_sensor/: app_motion_sensor.h
  group include-stream
    ../../../src/modules/app/src/app_project/remote_audio/stream/: app_stream.h
  group include-system
    ../../../src/modules/app/src/app_project/remote_audio/system/: app_sleep.h periph_setup.h
  group include-app_utils
    ../../../src/modules/app/src/app_utils/app_console/: app_console.h
    ../../../src/modules/app/src/app_utils/app_dbg/: app_dbg.h
    ../../../src/modules/app/src/app_utils/app_flash/: app_flash.h
    ../../../src/modules/app/src/app_utils/app_multi_bond/: app_con_fsm.h app_con_fsm_debug.h app_con_fsm_task.h app_multi_bond.h app_white_list.h
    ../../../src/modules/app/src/app_utils/: app_utils.h
  group boot
    ../../../src/plf/refip/src/arch/boot/rvds/: boot_vectors.s system_ARMCM0.c
  group driver
    ../../../src/plf/refip/src/driver/adc/: adc.c
    ../../../src/plf/refip/src/driver/battery/: battery.c
    ../../../src/plf/refip/src/driver/gpio/: gpio.c
    ../../../src/plf/refip/src/driver/i2c_BMI055/: i2c_bmi055.c
    ../../../src/plf/refip/src/driver/i2c_eeprom/: i2c_eeprom.c
    ../../../src/plf/refip/src/driver/pwm/: pwm.c
    ../../../src/modules/rf/src/: rf_580.c
    ../../../src/plf/refip/src/driver/spi/: spi.c
    ../../../src/plf/refip/src/driver/spi_439/: spi_439.c
    ../../../src/plf/refip/src/driver/spi_flash/: spi_flash.c
    ../../../src/plf/refip/src/driver/syscntl/: syscntl.c
    ../../../src/plf/refip/src/driver/wkupct_quadec/: wkupct_quadec.c
  group host
    ../../../src/ip/ble/hl/src/host/gap/gapm/: gapm.c
  group nvds
    ../../../src/modules/nvds/src/: nvds.c
  group patches
    ../../../patch_code/DA14580/obj/: atts_task.obj ch_map.obj gapm_util.obj ke_mem.obj ke_task.obj smpc.obj smpc_task.obj llc.obj
  group profiles
    ../../../src/ip/ble/hl/src/profiles/bas/bass/: bass.c bass_task.c
    ../../../src/ip/ble/hl/src/profiles/dis/diss/: diss.c diss_task.c
    ../../../src/ip/ble/hl/src/profiles/hogp/hogpd/: hogpd.c hogpd_task.c
    ../../../src/ip/ble/hl/src/profiles/: prf_utils.c
  group rwble
    ../../../src/ip/ble/ll/src/rwble/: rwble.c
    ../../../src/modules/rwip/src/: rwip.c
